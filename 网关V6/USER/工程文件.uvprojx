# Keil uVision project 工程文件.uvprojx, settings and files
target STM32G0x0工程 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G070RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: 工程文件 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G070xx
  c include: ..\CMSIS\Include;..\STM32G0xx_HAL_Driver\Inc;..\HARDWARE\Inc;..\CMSIS\Device\ST\STM32G0xx\Include;..\USER;..\HMAC\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x19000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/Scr/: stm32g0xx_it.c usart.c lora.c clock.c crc.c timer.c mqtt.c key_capture.c wifi_cat1.c
  group STM32G0xx_HAL_Driver
    ../STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_gpio.c stm32g0xx_hal_rcc.c stm32g0xx_hal_cortex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_crc.c stm32g0xx_hal_crc_ex.c
  group CMSIS
    ../CMSIS/Device/ST/STM32G0xx/Source/: system_stm32g0xx.c startup_stm32g070xx.s
  group HMAC
    ../HMAC/scr/: utils_hmac.c utils_md5.c utils_sha1.c
